# Keil uVision project standard.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: standard
  AfterMake: fromelf.exe  --bin -o ./bin/standard.bin ../build/MDK-ARM/@p.axf
  AfterMake: fromelf.exe  -c ../build/MDK-ARM/@p.axf -o ./bin/standard.lss
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\bsp\cubemx\Core\Inc;..\bsp\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc;..\bsp\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\bsp\cubemx\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\bsp\cubemx\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\bsp\cubemx\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\bsp\cubemx\Drivers\CMSIS\Include;..\bsp\cubemx\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\bsp\cubemx\Middlewares\Third_Party\FreeRTOS\Source\include;..\bsp\cubemx\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\bsp\cubemx\USB_DEVICE\App;..\bsp\cubemx\USB_DEVICE\Target;..\bsp\boards;..\components\algorithm;..\components\devices;..\components\modules;..\components\object;..\components\support;..\application;..\components\controller;..\components\bmi088;..\components\bmi088\include;..\components\log;..\components\protocol;..\components\soft_timer;..\components\easyflash\inc;..\components\cli;..\components\event_mgr;..\application\chassis;..\components\referee;..\bsp\boards;..\components\systemview;..\application\gimbal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ../application/: init.c app_manage.c communicate.c offline_service.c sensor_task.c shell.c event.h infantry_cmd.h appcfg.h oled_task.c voltage_task.c
  group chassis_app
    ../application/chassis/: chassis_app.c chassis_task.c chassis_cmd.c
  group gimbal_app
    ../application/gimbal/: gimbal_app.c gimbal_task.c shoot_task.c gimbal_cmd.c
  group boards
    ../bsp/boards/: board.c stm32f4xx_it.c drv_can.c drv_uart.c drv_dr16.c drv_flash.c drv_io.c drv_bmi088.c usbd_cdc_if.c bsp_adc.c
  group bmi088
    ../components/bmi088/: AHRS_middleware.c BMI088driver.c BMI088Middleware.c user_lib.c AHRS.lib arm_cortexM4lf_math.lib
  group device
    ../components/devices/: device.c motor.c dbus.c single_gyro.c ssd1306.c ssd1306_fonts.c
  group ez_flash
    ../components/easyflash/port/: ef_port.c
    ../components/easyflash/inc/: ef_cfg.h ef_def.h easyflash.h
    ../components/easyflash/src/: easyflash.c ef_env.c ef_utils.c
  group cli
    ../components/cli/: cli_history.c cli_interpreter.c cli_process.c
  group event_mgr
    ../components/event_mgr/: event_mgr.c memory_mgr.c
  group log
    ../components/log/: log.c log.h log_config.h
  group systemview
    ../components/systemview/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group referee
    ../components/referee/: referee_system.c referee_system.h
  group modules
    ../components/modules/: chassis.c gimbal.c shoot.c
  group algorithm
    ../components/algorithm/: mecanum.c pid.c ramp.c
  group soft_timer
    ../components/soft_timer/: soft_timer.c os_timer.c period.c
  group protocol
    ../components/protocol/: protocol.c protocol_common.c protocol_interface.c protocol_transmit.c protocol_cfg.h protocol_log.h
  group support
    ../components/support/: sys.h errno.h fifo.c fifo.h mem_mang4.c mem_mang.h mf_crc.c mf_crc.h linux_list.h
  group freertos
    ../bsp/cubemx/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../bsp/cubemx/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../bsp/cubemx/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../bsp/cubemx/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group cubemx
    ../bsp/cubemx/Core/Src/: can.c dma.c freertos.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c system_stm32f4xx.c tim.c usart.c i2c.c rng.c adc.c
  group usb_device
    ../bsp/cubemx/USB_DEVICE/App/: usb_device.c usbd_desc.c
    ../bsp/cubemx/USB_DEVICE/Target/: usbd_conf.c
    ../bsp/cubemx/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../bsp/cubemx/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group stm32f4xx_hal
    ../bsp/cubemx/MDK-ARM/: startup_stm32f407xx.s
    ../bsp/cubemx/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
software components: CMSIS:CORE 5.2.0
